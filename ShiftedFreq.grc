options:
  parameters:
    generate_options: qt_gui
    id: ShiftedFreq
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: rmt_delta_freq
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1024000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: rmt_delta_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '1000'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: '2523200000'
    clock_rate: 30.72e6
    dev_addr: '"serial=32CAB7A"'
    gain0: '80'
    samp_rate: '1000000'
    stream_args: peak=0.003906
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: '2523200000'
    clock_rate: 30.72e6
    dev_addr: '"serial=32CAB89"'
    gain0: '80'
    samp_rate: '1000000'
    stream_args: peak=0.003906
    sync: none
    type: fc32
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '8000'
  states: {}

connections:
- [analog_const_source_x_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_const_source_x_0, '0', qtgui_time_sink_x_0, '0']
- [analog_const_source_x_0, '0', uhd_usrp_sink_0, '0']
- [analog_const_source_x_0, '0', uhd_usrp_sink_0_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_xx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_multiply_xx_0, '0', uhd_usrp_sink_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
